# Keil uVision project STC12-SIM.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: STC12-SIM
  c flags: Optimize=8 SizeSpeed=1
  link misc: REMOVEUNUSED
  group Src
    ./: main.c OutPut_Control.c GSMCard.c Bluetooth.c
  group Device
    ./: UART1-Bluetooth.c UART2-SIMCard.c Command.c Command.h
  group Head
    ./: type.h Bluetooth.h GSMCard.h OutPut_Control.h
